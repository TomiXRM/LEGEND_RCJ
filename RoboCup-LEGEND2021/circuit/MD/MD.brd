# Repository TomiXRM/LEGEND_RCJ

File README.md:

# LEGEND_RoboCupJunior# LEGEND_RCJ

## EAGLE design RoboCup-LEGEND2021/circuit/MD/MD.brd

File RoboCup-LEGEND2021/README.md:

# RoboCup-LEGEND2021
 
# LEGEND_RCJ

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C11, C12, C13: 0.1uF; 0603
C9: C-PR-3,5X8; E3,5-8
R1: 1; 0603
R2: 47k; 0603
U$1: DRV8432DKDR; HSSOP-36
U$2: BAT
X1, X2: JST-XH-02-PIN-LONG-PAD; JST-XH-02-PACKAGE-LONG-PAD
X3: JST-XH-04-PIN-ROUND-PAD; JST-XH-04-PACKAGE-ROUND-PAD

Connections:
AGND1: C8.1, R1.1, R2.1, U$1.AGND, U$1.M3
GND: C1.1, C2.1, C3.2, C9.-, C11.1, C12.2, C13.1, R1.2, U$1.GND, U$1.GND_A, U$1.GND_B, U$1.GND_C, U$1.GND_D, U$1.PWM_B, U$1.PWM_D, U$2.G (-), X3.1
M1_1: C7.2, U$1.OUT_A, X1.2
M1_2: C5.2, U$1.OUT_B, X1.1
M2_1: C4.2, U$1.OUT_C, X2.2
M2_2: C6.2, U$1.OUT_D, X2.1
MDRST: U$1.RESET_AB (ESET_AB), U$1.RESET_CD, X3.2
unnamed: C6.1, U$1.BST_D
unnamed: C4.1, U$1.BST_C
unnamed: C5.1, U$1.BST_B
unnamed: C7.1, U$1.BST_A
unnamed: R2.2, U$1.OC_ADJ
PWM1: U$1.PWM_A, X3.4
PWM2: U$1.PWM_C, X3.3
VM: C1.2, C2.2, C3.1, C9.+, C11.2, C12.1, C13.2, U$1.GVDD_A, U$1.GVDD_B, U$1.GVDD_C, U$1.GVDD_D, U$1.PVDD_A, U$1.PVDD_B, U$1.PVDD_C, U$1.PVDD_D, U$1.VDD, U$2.+
VREG1: C8.2, U$1.M1, U$1.M2, U$1.VREG

Board: 2 copper layers, 40.0 x 28.0 mm, 19 parts (6 on the bottom side), 16 nets.

## EAGLE design RoboCup-LEGEND2021/circuit/KickerBoost/KickerBoost.brd

Parts:
C1: CPOL-EUE5-8.5; E5-8,5
C2: 1000pF; 0603
C3: 330pF; 0603
C4: CPOL-EUE5-10.5; E5-10,5
CON1, CON4, CON5: XT30UPB-M
D1, D2: MRA4007T3G; DIOM5226X290N
IC1: MC34063AD; SOIC8
L1: CDRH127/LD
Q1: BCX71SMD; SOT23
Q2: K13A60D; TO220BV
R1: 0.2; KH208-8
R2, R4, R7, R8: 1k; 0603
R3: 680; 0603
R5: 1M; 0603
R6: 10K; S64W
U1: TK10P50W
X1: VH2; B2P-VH-FB-B
X2: HX2; JST-XH-02-PACKAGE-LONG-PAD

Connections:
COIL: Q2.D, X1.1
GND: C1.-, C4.-, CON1.-, CON4.-, CON5.-, IC1.4 (GND), Q1.3 (C), Q2.S, R4.1, R6.A (VDD), R8.1, U1.3 (SOURCE), X2.2
unnamed: C2.2, C3.2
unnamed: Q2.G, R7.1, R8.2
unnamed: D2.1 (C), Q1.2 (E), U1.1 (GATE)
unnamed: C2.1, C3.1, IC1.3 (TC)
unnamed: IC1.1 (SWC), R2.1
unnamed: IC1.8 (DC), R3.1
PWM: R7.2, X2.1
SE: D2.2 (A), IC1.2 (SWE), Q1.1 (B), R4.2
V$4: IC1.7 (IS), L1.1, R1.2, R2.2, R3.2
V$5: D1.2 (A), L1.2, U1.2 (DRAIN)
VAR: IC1.5 (FB), R5.1, R6.E (VSS), R6.S (OUT)
VIN: C1.+, CON1.+, IC1.6 (VCC), R1.1
V_HIGH: C4.+, CON4.+, CON5.+, D1.1 (C), R5.2, X1.2

Notes on the sheet:
10k
Kicker pin
VIN
VOUT
Capacitor input
Kick control
Trigger input

Board: 2 copper layers, 48.6 x 36.8 mm, 24 parts (0 on the bottom side), 15 nets.

## EAGLE design RoboCup-LEGEND2021/circuit/LEGEND2022/main.brd

Parts:
BEAD: 0; 0603
C1: 0.1uF; 1608
C2, C3, C4, C5, C6, C7, C10, C11, C12, C13, C15, C17, C18, C19, C20, C22, C24, C30: 0.1UF_1608; 1608
C8: 4.7uF; 0603
C9, C34: 0.1uF; 0603
C26: 0.001UF_1608; 1608
C28, C29: 1.0UF_1608; 1608
CAM: cam; B4B-XH-A
CHK, CHK1: +3V3; 1X02
CN1: 1; JST-XH-03-PACKAGE-LONG-PAD
CN2: 2; JST-XH-03-PACKAGE-LONG-PAD
CN3: 3; JST-XH-03-PACKAGE-LONG-PAD
CN4: 4; JST-XH-03-PACKAGE-LONG-PAD
D1: DIODE-SS2040LFL; SOD123FL
DRIB: B3B-XH-A
IR: IR; B4B-XH-A
J1: CONN_04; 1X04
LED1, LED2: LED-SMD; LED-1206
LINE: FH12-12S-0.5SH
MD_A: B6B-XH-A
NUCLEO_MAIN: F446RET6; STM32F446RET6
PILOT: LED-SMD; LED-1206
R1, R2, R4, R5, R6, R9: 1k; R0603
R3: 10k; R0603
SP: PKLCS1212E4001
STLINK: MAIN; B6B-XH-A
SUPPLY: B4B-XH-A
UART3, UART4, UART5, UART6: IMU; B4B-XH-A
UI: FH12-12S-0.5SH

Connections:
+5V: C6.2, CAM.2, SUPPLY.3
BALLRX: IR.2, NUCLEO_MAIN.PA3
BOOT0: NUCLEO_MAIN.BOOT0, R3.2
BUTTON_CENTER: NUCLEO_MAIN.PC14, UI.5
BUTTON_LEFT: NUCLEO_MAIN.PC15, UI.4
BUTTON_RIGHT: NUCLEO_MAIN.PC13, UI.6
BUZZER: NUCLEO_MAIN.PA11, R9.1
CN1: CN1.3, NUCLEO_MAIN.PC0
CN2: CN2.3, NUCLEO_MAIN.PC1
CN3: CN3.3, NUCLEO_MAIN.PC2
CN4: CN4.3, NUCLEO_MAIN.PC3
DRIB_PWM: DRIB.3, NUCLEO_MAIN.PB10
LED1: LED1.A, NUCLEO_MAIN.PH1
LED2: LED2.A, NUCLEO_MAIN.PH0
LINE_A0: LINE.6, NUCLEO_MAIN.PB12
LINE_A1: LINE.5, NUCLEO_MAIN.PB13
LINE_A2: LINE.4, NUCLEO_MAIN.PB14
LINE_A3: LINE.3, NUCLEO_MAIN.PB15
LINE_A4: LINE.2, NUCLEO_MAIN.PC8
LINE_ANALOG: LINE.1, NUCLEO_MAIN.PB1
LINE_PWM: LINE.7, NUCLEO_MAIN.PB2
unnamed: LED2.C, R2.1
unnamed: LED1.C, R4.1
NRST: C2.1, NUCLEO_MAIN.NRST, STLINK.2
PH1: MD_A.2, NUCLEO_MAIN.PB3
PH2: MD_A.3, NUCLEO_MAIN.PB4
PH3: MD_A.4, NUCLEO_MAIN.PB5
PH4: MD_A.5, NUCLEO_MAIN.PB6
POWERLED_RESISTOR: PILOT.A, R1.1
RGB_B: NUCLEO_MAIN.PA12, UI.3
RGB_G: NUCLEO_MAIN.PA8, UI.2
RGB_R: NUCLEO_MAIN.PC9, UI.1
SCL: CHK1.1, J1.2, NUCLEO_MAIN.PB8, R6.1, UI.7
SDA: CHK1.2, J1.1, NUCLEO_MAIN.PB9, R5.1, UI.8
SERIAL1RX: CAM.3, NUCLEO_MAIN.PA10
SERIAL1TX: CAM.4, NUCLEO_MAIN.PA9
SERIAL3RX: NUCLEO_MAIN.PC11, UART3.4
SERIAL3TX: NUCLEO_MAIN.PC10, UART3.3
SERIAL4RX: NUCLEO_MAIN.PA1, UART4.4
SERIAL4TX: NUCLEO_MAIN.PA0, UART4.3
SERIAL5RX: NUCLEO_MAIN.PD2, UART5.4
SERIAL5TX: NUCLEO_MAIN.PC12, UART5.3
SERIAL6RX: NUCLEO_MAIN.PC7, UART6.4
SERIAL6TX: NUCLEO_MAIN.PC6, UART6.3
SLEEP: MD_A.6, NUCLEO_MAIN.PB7
SP: D1.C, R9.2, SP.1
SWCLK: NUCLEO_MAIN.PA14, STLINK.4
SWDIO: NUCLEO_MAIN.PA13, STLINK.3
USBTX: NUCLEO_MAIN.PA2, STLINK.1
VBAT: SUPPLY.4
VCAP: C8.1, NUCLEO_MAIN.VCAP_1
VCC: BEAD.2, C1.1, C3.2, C4.1, C5.2, C7.1, C9.1, C10.2, C11.2, C12.1, C13.1, C15.1, C17.1, C18.1, C19.1, C20.1, C22.1, C24.1, C26.1, C28.1, C29.1, C30.2, C34.1, CHK.1, CN1.2, CN2.2, CN3.2, CN4.2, DRIB.2, IR.4, J1.4, LINE.8, LINE.9, NUCLEO_MAIN.VBAT, NUCLEO_MAIN.VDD, NUCLEO_MAIN.VDD1, NUCLEO_MAIN.VDD2, NUCLEO_MAIN.VDD3, R1.2, R5.2, R6.2, STLINK.5, SUPPLY.2, UART3.2, UART4.2, UART5.2, UART6.2, UI.9, UI.10
VDDA: BEAD.1, NUCLEO_MAIN.VREF+
VSS: C1.2, C2.2, C3.1, C4.2, C5.1, C6.1, C7.2, C8.2, C9.2, C10.1, C11.1, C12.2, C13.2, C15.2, C17.2, C18.2, C19.2, C20.2, C22.2, C24.2, C26.2, C28.2, C29.2, C30.1, C34.2, CAM.1, CHK.2, CN1.1, CN2.1, CN3.1, CN4.1, D1.A, DRIB.1, IR.3, J1.3, LINE.10, LINE.11, LINE.12, MD_A.1, NUCLEO_MAIN.VREF-, NUCLEO_MAIN.VSS, NUCLEO_MAIN.VSS1, NUCLEO_MAIN.VSS2, NUCLEO_MAIN.VSS3, PILOT.C, R2.2, R3.1, R4.2, SP.2, STLINK.6, SUPPLY.1, UART3.1, UART4.1, UART5.1, UART6.1, UI.11, UI.12

Notes on the sheet:
Note: UARTピンの名称は全てSTM32F446REからみた名称
VCC:3.3V
Jumpers: NO : normaly Open NC : normally close(Connected)
VDD:+3V3
VSS:GND
Motor
serial
analog

Board: 2 copper layers, 68.4 x 46.1 mm, 58 parts (19 on the bottom side), 53 nets.

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
inductor-sumida: Copyright (C) 2008, Bob Starr
cap-pan40: Copyright (C) 2004, Bob Starr
